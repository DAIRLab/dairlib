Commit message: updating cassie sims

File: examples/contact_parameter_learning/urdf/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=5 5 1; visual box size=5 5 1
