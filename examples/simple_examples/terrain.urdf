Commit message: adding paramter study for walking

File: examples/simple_examples/terrain.urdf (robot description, URDF)
Before this commit: robot terrain, 1 links, 0 joints
Links:
- link base: geometry collision box size=0.5 1.0 0.1; visual box size=0.5 1.0 0.1
